Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Bond - Lounge Armchair - ver4.ifc
Time: 2025-11-04T15:14:48
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (26)
Name
 | Bond - Lounge Armchair_0 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_1 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_2 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_3 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_4 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_5 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_6 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_7 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_8 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_9 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_10 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_11 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_12 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_13 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_14 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_15 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_16 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_17 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_18 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_19 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_20 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_21 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_22 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_23 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_24 - ObjectType: SketchupGroup
 | Bond - Lounge Armchair_25 - ObjectType: SketchupGroup
